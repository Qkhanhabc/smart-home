/* 
  Code Test Hồng Ngoại (Khuếch đại qua Transistor 2N2222)
  Chân kết nối:
  - Mat thu IR (D17)
  - Mat phat IR qua chân B của Transistor (D22)
*/

#include <Arduino.h>
#include <IRremoteESP8266.h>
#include <IRsend.h>
#include <IRrecv.h>
#include <IRutils.h> 

const uint16_t IR_RECV_PIN = 17;
const uint16_t IR_SEND_PIN = 22;

// Tăng thời gian chờ lên 50ms để bắt trọn bộ lệnh dài của điều hòa Toshiba
IRrecv irrecv(IR_RECV_PIN, 1024, 50, true); 
decode_results ir_results;
IRsend irsend(IR_SEND_PIN);

// =======================================================
// DÁN MÃ BẬT / TẮT (RAW DATA) MỚI VÀO ĐÂY
// =======================================================
uint16_t ac_on_code[] = {4444, 4336,  594, 1556,  596, 476,  600, 1554,  596, 1554,  594, 478,  596, 480,  596, 1556,  594, 478,  596, 478,  598, 1556,  592, 480,  598, 476,  598, 1556,  594, 1556,  598, 478,  596, 1552,  598, 478,  596, 478,  596, 478,  596, 1554,  596, 1558,  592, 1556,  596, 1552,  598, 1558,  592, 1556,  596, 1558,  592, 1582,  568, 480,  596, 480,  594, 478,  596, 480,  598, 478,  594, 1558,  592, 1558,  594, 480,  596, 1554,  592, 1584,  568, 480,  598, 478,  598, 478,  592, 480,  596, 480,  596, 1558,  592, 480,  598, 476,  596, 1556,  592, 1558,  592, 1584,  568, 5152,  4452, 4336,  594, 1558,  590, 484,  594, 1558,  590, 1562,  590, 482,  592, 484,  592, 1560,  590, 482,  592, 484,  592, 1558,  588, 486,  594, 484,  588, 1562,  588, 1562,  592, 482,  590, 1562,  588, 486,  592, 482,  594, 482,  590, 1560,  590, 1560,  564, 1588,  562, 1586,  588, 1564,  560, 1590,  562, 1588,  562, 1586,  562, 512,  596, 480,  596, 478,  598, 478,  588, 488,  590, 1560,  564, 1586,  590, 486,  594, 1556,  590, 1560,  592, 482,  596, 476,  598, 478,  592, 480,  600, 478,  600, 1550,  588, 484,  602, 472,  600, 1552,  592, 1558,  594, 1556,  598};
uint16_t ac_off_code[] = {4456, 4332,  596, 1580,  544, 504,  602, 1552,  592, 1556,  596, 478,  600, 476,  602, 1576,  570, 478,  598, 478,  600, 1554,  594, 478,  600, 476,  598, 1578,  570, 1584,  566, 478,  596, 1556,  596, 478,  596, 1554,  572, 1582,  594, 1556,  594, 1556,  594, 478,  598, 1580,  570, 1556,  592, 1558,  596, 476,  596, 478,  598, 478,  596, 478,  602, 1554,  592, 478,  598, 478,  596, 1556,  594, 1556,  594, 1558,  594, 476,  596, 478,  596, 480,  594, 478,  598, 478,  594, 482,  596, 478,  572, 504,  572, 1606,  554, 1572,  568, 1582,  568, 1582,  594, 1556,  594, 5148,  4456, 4332,  596, 1556,  594, 480,  570, 1580,  570, 1582,  592, 482,  592, 480,  602, 1552,  570, 504,  594, 482,  594, 1560,  592, 478,  594, 482,  570, 1580,  592, 1560,  588, 484,  594, 1556,  590, 486,  590, 1560,  588, 1562,  584, 1566,  592, 1562,  588, 486,  584, 1566,  590, 1560,  590, 1560,  568, 506,  568, 508,  568, 508,  570, 504,  596, 1556,  562, 510,  598, 478,  590, 1562,  562, 1588,  590, 1560,  590, 482,  594, 482,  594, 480,  602, 474,  598, 474,  598, 478,  596, 476,  604, 472,  600, 1552,  592, 1560,  592, 1556,  592, 1560,  590, 1558,  596};
// =======================================================

void setup() {
  Serial.begin(115200);
  delay(1000);
  
  irsend.begin();      
  irrecv.enableIRIn(); 

  Serial.println("\n--- HE THONG TEST DIEU HOA (QUA TRANSISTOR) DA SAN SANG ---");
  Serial.println("1. Chia remote vao D17 de thu lai ma chuan.");
  Serial.println("2. Go 'B' hoac 'T' de ESP32 phat ma.");
}

void loop() {
  // 1. THU LẠI LỆNH MỚI (CHỐNG NHIễU, CHỐNG NGẮT)
  if (irrecv.decode(&ir_results)) {
    Serial.println("\n===== TIN HIEU REMOTE MOI =====");
    Serial.println(resultToSourceCode(&ir_results)); 
    Serial.println("===============================\n");
    irrecv.resume(); 
  }

  // 2. PHÁT LỆNH QUA TRANSISTOR
  if (Serial.available() > 0) {
    char cmd = Serial.read();

    if (cmd == 'B' || cmd == 'b') {
      Serial.println("=> Dang kich hoat Transistor (D22) phat lenh BAT...");
      irsend.sendRaw(ac_on_code, sizeof(ac_on_code)/sizeof(ac_on_code[0]), 38);
      irrecv.enableIRIn(); 
    } 
    else if (cmd == 'T' || cmd == 't') {
      Serial.println("=> Dang kich hoat Transistor (D22) phat lenh TAT...");
      irsend.sendRaw(ac_off_code, sizeof(ac_off_code)/sizeof(ac_off_code[0]), 38);
      irrecv.enableIRIn(); 
    }
  }
}